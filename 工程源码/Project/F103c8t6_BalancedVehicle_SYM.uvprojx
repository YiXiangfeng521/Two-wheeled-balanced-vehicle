# Keil uVision project F103c8t6_BalancedVehicle_SYM.uvprojx, settings and files
target BalancedVehicle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalancedVehicle +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,MPU6050,EMPL_TARGET_STM32F1
  c include: ..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User\adc;..\User\TimBase;..\User\usart;..\User\test;..\User\DCmotor_brush;..\User\LED;..\User\encoder;..\User\MPU6050;..\User\exti;..\User\FastMath
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STDPERIPH_DRIVER
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/adc/: adc.c
    ../User/TimBase/: Timbase.c
    ../User/usart/: usart.c
    ../User/test/: test.c
    ../User/DCmotor_brush/: DCmotor_brush_control.c
    ../User/LED/: led.c
    ../User/encoder/: encoder.c
    ../User/MPU6050/: mpu_soft_iic.c mpu6050.c
    ../User/exti/: exti.c
    ../User/FastMath/: fastmath.c
  group DOC
    ../Doc/: readme.txt
